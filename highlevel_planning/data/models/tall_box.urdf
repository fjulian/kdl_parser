Commit message: Fix object to gripper when grasping

File: highlevel_planning/data/models/tall_box.urdf (robot description, URDF)
Before this commit: robot tall_box.urdf, 2 links, 1 joints
Joints:
- joint blj: origin xyz=0 0 0 rpy=0 0 0.07 -> xyz=0 0 0 rpy=0 0 0
